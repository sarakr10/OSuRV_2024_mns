File: Embedded/AC_Logger/HW/AFE/Amp.kicad_sch (KiCad schematic)
At the start: 12 parts

Commit message: Updated to new KiCAD version.
